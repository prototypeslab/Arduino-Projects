# Keil uVision project NucleoF401GestureDetect1.uvprojx, settings and files
target NucleoF401GestureDetect1 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NucleoF401GestureDetect1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-6180XA1;..\..\..\..\..\..\..\Drivers\BSP\Components\vl6180x;..\..\Inc;..\..\..\..\..\..\..\Middlewares\ST\Gestures\GesturesDetect\Inc;..\..\..\..\..\..\..\Middlewares\ST\Gestures\GesturesDetect\Inc\diag
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
    ../../../../../../../Drivers/BSP/X-NUCLEO-6180XA1/: x-nucleo-6180xa1.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
  group VL6180xAPI
    ../../../../../../../Drivers/BSP/Components/vl6180x/: vl6180x_api.c vl6180x_i2c.c
  group Gestures
    ../../../../../../../Middlewares/ST/Gestures/GesturesDetect/Src/: ring_buffer.c tof_motion.c tof_gestures_DIRSWIPE_1.c tof_gestures_TAP_SWIPE_2.c tof_gestures_TAP_1.c
  group Trace
    ../../../../../../../Middlewares/ST/Gestures/GesturesDetect/Src/diag/: Trace.c trace_impl.c
